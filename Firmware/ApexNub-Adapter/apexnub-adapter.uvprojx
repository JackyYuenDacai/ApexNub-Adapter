# Keil uVision project apexnub-adapter.uvprojx, settings and files
target Adapter-Firmware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00800000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: apexnub-adapter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG  CONFIG_NFCT_PINS_AS_GPIOS=1 APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52833_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\config;.\nRF5_SDK_17.1.0\components;.\nRF5_SDK_17.1.0\components\ble\ble_advertising;.\nRF5_SDK_17.1.0\components\ble\ble_dtm;.\nRF5_SDK_17.1.0\components\ble\ble_link_ctx_manager;.\nRF5_SDK_17.1.0\components\ble\ble_racp;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ancs_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ans_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_bas;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_bas_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_cscs;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_cts_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_dfu;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_dis;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_gls;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hids;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hrs;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hrs_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hts;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ias;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ias_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_lbs;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_lbs_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_lls;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_nus;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_nus_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_rscs;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_rscs_c;.\nRF5_SDK_17.1.0\components\ble\ble_services\ble_tps;.\nRF5_SDK_17.1.0\components\ble\common;.\nRF5_SDK_17.1.0\components\ble\nrf_ble_gatt;.\nRF5_SDK_17.1.0\components\ble\nrf_ble_qwr;.\nRF5_SDK_17.1.0\components\ble\peer_manager;.\nRF5_SDK_17.1.0\components\boards;.\nRF5_SDK_17.1.0\components\libraries\atomic;.\nRF5_SDK_17.1.0\components\libraries\atomic_fifo;.\nRF5_SDK_17.1.0\components\libraries\atomic_flags;.\nRF5_SDK_17.1.0\components\libraries\balloc;.\nRF5_SDK_17.1.0\components\libraries\bootloader\ble_dfu;.\nRF5_SDK_17.1.0\components\libraries\bsp;.\nRF5_SDK_17.1.0\components\libraries\button;.\nRF5_SDK_17.1.0\components\libraries\cli;.\nRF5_SDK_17.1.0\components\libraries\crc16;.\nRF5_SDK_17.1.0\components\libraries\crc32;.\nRF5_SDK_17.1.0\components\libraries\crypto;.\nRF5_SDK_17.1.0\components\libraries\csense;.\nRF5_SDK_17.1.0\components\libraries\csense_drv;.\nRF5_SDK_17.1.0\components\libraries\delay;.\nRF5_SDK_17.1.0\components\libraries\ecc;.\nRF5_SDK_17.1.0\components\libraries\experimental_section_vars;.\nRF5_SDK_17.1.0\components\libraries\experimental_task_manager;.\nRF5_SDK_17.1.0\components\libraries\fds;.\nRF5_SDK_17.1.0\components\libraries\fstorage;.\nRF5_SDK_17.1.0\components\libraries\gfx;.\nRF5_SDK_17.1.0\components\libraries\gpiote;.\nRF5_SDK_17.1.0\components\libraries\hardfault;.\nRF5_SDK_17.1.0\components\libraries\hci;.\nRF5_SDK_17.1.0\components\libraries\led_softblink;.\nRF5_SDK_17.1.0\components\libraries\log;.\nRF5_SDK_17.1.0\components\libraries\log\src;.\nRF5_SDK_17.1.0\components\libraries\low_power_pwm;.\nRF5_SDK_17.1.0\components\libraries\mem_manager;.\nRF5_SDK_17.1.0\components\libraries\memobj;.\nRF5_SDK_17.1.0\components\libraries\mpu;.\nRF5_SDK_17.1.0\components\libraries\mutex;.\nRF5_SDK_17.1.0\components\libraries\pwm;.\nRF5_SDK_17.1.0\components\libraries\pwr_mgmt;.\nRF5_SDK_17.1.0\components\libraries\queue;.\nRF5_SDK_17.1.0\components\libraries\ringbuf;.\nRF5_SDK_17.1.0\components\libraries\scheduler;.\nRF5_SDK_17.1.0\components\libraries\sdcard;.\nRF5_SDK_17.1.0\components\libraries\sensorsim;.\nRF5_SDK_17.1.0\components\libraries\slip;.\nRF5_SDK_17.1.0\components\libraries\sortlist;.\nRF5_SDK_17.1.0\components\libraries\spi_mngr;.\nRF5_SDK_17.1.0\components\libraries\stack_guard;.\nRF5_SDK_17.1.0\components\libraries\strerror;.\nRF5_SDK_17.1.0\components\libraries\svc;.\nRF5_SDK_17.1.0\components\libraries\timer;.\nRF5_SDK_17.1.0\components\libraries\twi_mngr;.\nRF5_SDK_17.1.0\components\libraries\twi_sensor;.\nRF5_SDK_17.1.0\components\libraries\usbd;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\audio;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc\acm;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\generic;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\kbd;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\mouse;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\msc;.\nRF5_SDK_17.1.0\components\libraries\util;.\nRF5_SDK_17.1.0\components\nfc\ndef\conn_hand_parser;.\nRF5_SDK_17.1.0\components\nfc\ndef\conn_hand_parser\ac_rec_parser;.\nRF5_SDK_17.1.0\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;.\nRF5_SDK_17.1.0\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;.\nRF5_SDK_17.1.0\components\nfc\ndef\connection_handover\ac_rec;.\nRF5_SDK_17.1.0\components\nfc\ndef\connection_handover\ble_oob_advdata;.\nRF5_SDK_17.1.0\components\nfc\ndef\connection_handover\ble_pair_lib;.\nRF5_SDK_17.1.0\components\nfc\ndef\connection_handover\ble_pair_msg;.\nRF5_SDK_17.1.0\components\nfc\ndef\connection_handover\common;.\nRF5_SDK_17.1.0\components\nfc\ndef\connection_handover\ep_oob_rec;.\nRF5_SDK_17.1.0\components\nfc\ndef\connection_handover\hs_rec;.\nRF5_SDK_17.1.0\components\nfc\ndef\connection_handover\le_oob_rec;.\nRF5_SDK_17.1.0\components\nfc\ndef\generic\message;.\nRF5_SDK_17.1.0\components\nfc\ndef\generic\record;.\nRF5_SDK_17.1.0\components\nfc\ndef\launchapp;.\nRF5_SDK_17.1.0\components\nfc\ndef\parser\message;.\nRF5_SDK_17.1.0\components\nfc\ndef\parser\record;.\nRF5_SDK_17.1.0\components\nfc\ndef\text;.\nRF5_SDK_17.1.0\components\nfc\ndef\uri;.\nRF5_SDK_17.1.0\components\nfc\platform;.\nRF5_SDK_17.1.0\components\nfc\t2t_lib;.\nRF5_SDK_17.1.0\components\nfc\t2t_parser;.\nRF5_SDK_17.1.0\components\nfc\t4t_lib;.\nRF5_SDK_17.1.0\components\nfc\t4t_parser\apdu;.\nRF5_SDK_17.1.0\components\nfc\t4t_parser\cc_file;.\nRF5_SDK_17.1.0\components\nfc\t4t_parser\hl_detection_procedure;.\nRF5_SDK_17.1.0\components\nfc\t4t_parser\tlv;.\nRF5_SDK_17.1.0\components\softdevice\common;.\nRF5_SDK_17.1.0\components\softdevice\s140\headers;.\nRF5_SDK_17.1.0\components\softdevice\s140\headers\nrf52;.\nRF5_SDK_17.1.0\external\fprintf;.\nRF5_SDK_17.1.0\external\segger_rtt;.\nRF5_SDK_17.1.0\external\utf_converter;.\nRF5_SDK_17.1.0\integration\nrfx;.\nRF5_SDK_17.1.0\integration\nrfx\legacy;.\nRF5_SDK_17.1.0\modules\nrfx;.\nRF5_SDK_17.1.0\modules\nrfx\drivers\include;.\nRF5_SDK_17.1.0\modules\nrfx\hal;nRF5_SDK_17.1.0\components;.\nRF5_SDK_17.1.0\components\boards;.\nRF5_SDK_17.1.0\components\drivers_nrf\nrf_soc_nosd;.\nRF5_SDK_17.1.0\components\libraries\atomic;.\nRF5_SDK_17.1.0\components\libraries\atomic_fifo;.\nRF5_SDK_17.1.0\components\libraries\balloc;.\nRF5_SDK_17.1.0\components\libraries\bsp;.\nRF5_SDK_17.1.0\components\libraries\button;.\nRF5_SDK_17.1.0\components\libraries\cli;.\nRF5_SDK_17.1.0\components\libraries\cli\uart;.\nRF5_SDK_17.1.0\components\libraries\delay;.\nRF5_SDK_17.1.0\components\libraries\experimental_section_vars;.\nRF5_SDK_17.1.0\components\libraries\fifo;.\nRF5_SDK_17.1.0\components\libraries\hardfault;.\nRF5_SDK_17.1.0\components\libraries\hardfault\nrf52;.\nRF5_SDK_17.1.0\components\libraries\log;.\nRF5_SDK_17.1.0\components\libraries\log\src;.\nRF5_SDK_17.1.0\components\libraries\memobj;.\nRF5_SDK_17.1.0\components\libraries\mutex;.\nRF5_SDK_17.1.0\components\libraries\pwr_mgmt;.\nRF5_SDK_17.1.0\components\libraries\queue;.\nRF5_SDK_17.1.0\components\libraries\ringbuf;.\nRF5_SDK_17.1.0\components\libraries\scheduler;.\nRF5_SDK_17.1.0\components\libraries\sortlist;.\nRF5_SDK_17.1.0\components\libraries\strerror;.\nRF5_SDK_17.1.0\components\libraries\timer;.\nRF5_SDK_17.1.0\components\libraries\uart;.\nRF5_SDK_17.1.0\components\libraries\usbd;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\generic;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\kbd;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\mouse;.\nRF5_SDK_17.1.0\components\libraries\util;.\nRF5_SDK_17.1.0\external\fnmatch;.\nRF5_SDK_17.1.0\external\fprintf;.\nRF5_SDK_17.1.0\external\segger_rtt;.\nRF5_SDK_17.1.0\external\utf_converter;.\nRF5_SDK_17.1.0\integration\nrfx;.\nRF5_SDK_17.1.0\integration\nrfx\legacy;.\nRF5_SDK_17.1.0\modules\nrfx;.\nRF5_SDK_17.1.0\modules\nrfx\drivers\include;.\nRF5_SDK_17.1.0\modules\nrfx\hal;.\Inc;.\nRF5_SDK_17.1.0\components\softdevice\s140\headers\nrf52;.\nRF5_SDK_17.1.0\components\softdevice\s140\headers;.\nRF5_SDK_17.1.0\components\ble\nrf_ble_gatt;.\nRF5_SDK_17.1.0\components\softdevice\common;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cc310;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cc310_bl;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\mbedtls;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\micro_ecc;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\optiga;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\oberon;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cifra;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\nrf_hw;.\nRF5_SDK_17.1.0\components\libraries\crypto\backend\nrf_sw
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DCONFIG_NFCT_PINS_AS_GPIOS=1,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10100,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52833_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: nRF5_SDK_17.1.0\components;.\nRF5_SDK_17.1.0\components\boards;.\nRF5_SDK_17.1.0\components\drivers_nrf\nrf_soc_nosd;.\nRF5_SDK_17.1.0\components\libraries\atomic;.\nRF5_SDK_17.1.0\components\libraries\atomic_fifo;.\nRF5_SDK_17.1.0\components\libraries\balloc;.\nRF5_SDK_17.1.0\components\libraries\bsp;.\nRF5_SDK_17.1.0\components\libraries\button;.\nRF5_SDK_17.1.0\components\libraries\cli;.\nRF5_SDK_17.1.0\components\libraries\cli\uart;.\nRF5_SDK_17.1.0\components\libraries\delay;.\nRF5_SDK_17.1.0\components\libraries\experimental_section_vars;.\nRF5_SDK_17.1.0\components\libraries\fifo;.\nRF5_SDK_17.1.0\components\libraries\hardfault;.\nRF5_SDK_17.1.0\components\libraries\hardfault\nrf52;.\nRF5_SDK_17.1.0\components\libraries\log;.\nRF5_SDK_17.1.0\components\libraries\log\src;.\nRF5_SDK_17.1.0\components\libraries\memobj;.\nRF5_SDK_17.1.0\components\libraries\mutex;.\nRF5_SDK_17.1.0\components\libraries\pwr_mgmt;.\nRF5_SDK_17.1.0\components\libraries\queue;.\nRF5_SDK_17.1.0\components\libraries\ringbuf;.\nRF5_SDK_17.1.0\components\libraries\scheduler;.\nRF5_SDK_17.1.0\components\libraries\sortlist;.\nRF5_SDK_17.1.0\components\libraries\strerror;.\nRF5_SDK_17.1.0\components\libraries\timer;.\nRF5_SDK_17.1.0\components\libraries\uart;.\nRF5_SDK_17.1.0\components\libraries\usbd;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\generic;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\kbd;.\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\mouse;.\nRF5_SDK_17.1.0\components\libraries\util;.\nRF5_SDK_17.1.0\external\fnmatch;.\nRF5_SDK_17.1.0\external\fprintf;.\nRF5_SDK_17.1.0\external\segger_rtt;.\nRF5_SDK_17.1.0\external\utf_converter;.\nRF5_SDK_17.1.0\integration\nrfx;.\nRF5_SDK_17.1.0\integration\nrfx\legacy;.\nRF5_SDK_17.1.0\modules\nrfx;.\nRF5_SDK_17.1.0\modules\nrfx\drivers\include;.\nRF5_SDK_17.1.0\modules\nrfx\hal;.\Inc;.\nRF5_SDK_17.1.0\components\softdevice\s140\headers\nrf52
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0x59000
  memory RVCT9: RAM 0x20002768 size 0x1d898
  memory RVCT10: RAM 0x800000 size 0x20000
  link misc: --diag_suppress 6330
  group Application
    ./Src/: main.c usb_service.c ble_cmd_service.c ble_config.c report_timer.c rtc_config.c ble_config_handler.c usbd_config.c
    ./Inc/: sdk_config.h ble_config.h
  group Board Definition
    ./nRF5_SDK_17.1.0/components/boards/: boards.c
  group Board Support
    ./nRF5_SDK_17.1.0/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ./nRF5_SDK_17.1.0/external/utf_converter/: utf.c
  group nRF_BLE
    ./nRF5_SDK_17.1.0/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ./nRF5_SDK_17.1.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ./nRF5_SDK_17.1.0/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ./nRF5_SDK_17.1.0/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ./nRF5_SDK_17.1.0/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ./nRF5_SDK_17.1.0/components/ble/ble_advertising/: ble_advertising.c
  group nRF_BLE_Services
    ./nRF5_SDK_17.1.0/components/ble/ble_services/ble_dis/: ble_dis.c
  group nRF_Drivers
    ./nRF5_SDK_17.1.0/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c
    ./nRF5_SDK_17.1.0/modules/nrfx/soc/: nrfx_atomic.c
    ./nRF5_SDK_17.1.0/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_rtc.c nrfx_timer.c nrfx_rng.c
    ./nRF5_SDK_17.1.0/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ./nRF5_SDK_17.1.0/components/libraries/button/: app_button.c
    ./nRF5_SDK_17.1.0/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ./nRF5_SDK_17.1.0/components/libraries/scheduler/: app_scheduler.c
    ./nRF5_SDK_17.1.0/components/libraries/timer/: app_timer2.c drv_rtc.c
    ./nRF5_SDK_17.1.0/components/libraries/crc16/: crc16.c
    ./nRF5_SDK_17.1.0/components/libraries/fds/: fds.c
    ./nRF5_SDK_17.1.0/components/libraries/hardfault/: hardfault_implementation.c
    ./nRF5_SDK_17.1.0/components/libraries/atomic_fifo/: nrf_atfifo.c
    ./nRF5_SDK_17.1.0/components/libraries/atomic_flags/: nrf_atflags.c
    ./nRF5_SDK_17.1.0/components/libraries/atomic/: nrf_atomic.c
    ./nRF5_SDK_17.1.0/components/libraries/balloc/: nrf_balloc.c
    ./nRF5_SDK_17.1.0/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ./nRF5_SDK_17.1.0/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ./nRF5_SDK_17.1.0/components/libraries/memobj/: nrf_memobj.c
    ./nRF5_SDK_17.1.0/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ./nRF5_SDK_17.1.0/components/libraries/ringbuf/: nrf_ringbuf.c
    ./nRF5_SDK_17.1.0/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ./nRF5_SDK_17.1.0/components/libraries/sortlist/: nrf_sortlist.c
    ./nRF5_SDK_17.1.0/components/libraries/strerror/: nrf_strerror.c
    ./nRF5_SDK_17.1.0/components/libraries/queue/: nrf_queue.c
    ./nRF5_SDK_17.1.0/components/libraries/mem_manager/: mem_manager.c
    ./nRF5_SDK_17.1.0/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
  group nRF_Log
    ./nRF5_SDK_17.1.0/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ./nRF5_SDK_17.1.0/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nRF_SoftDevice
    ./nRF5_SDK_17.1.0/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group USBD
    ./nRF5_SDK_17.1.0/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_string_desc.c
    ./nRF5_SDK_17.1.0/components/libraries/usbd/class/hid/: app_usbd_hid.c
    ./nRF5_SDK_17.1.0/components/libraries/usbd/class/hid/generic/: app_usbd_hid_generic.c
    ./nRF5_SDK_17.1.0/modules/nrfx/drivers/src/: nrfx_usbd.c nrfx_power.c
    ./nRF5_SDK_17.1.0/integration/nrfx/legacy/: nrf_drv_power.c
target Softdevice (6160000::V6.16::ARMCLANG)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  asm define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x26000
  memory RVCT9: RAM 0x20000000 size 0x2260
  memory RVCT10: RAM 0x800000 size 0x20000
software components: CMSIS:CORE 5.1.1, CMSIS:CORE 6.1.1, Device:Startup 8.40.3, Device:Startup 8.44.1
